Commit message: urdf from the Sawyer Robot.

File: data/robot/rethink/sawyer_description/urdf/sawyer_arm_ctrl.urdf (robot description, URDF)
Before this commit: robot sawyer_no_base, 15 links, 14 joints
Links:
- link right_gripper_base: mass 0.3 -> 0.47
