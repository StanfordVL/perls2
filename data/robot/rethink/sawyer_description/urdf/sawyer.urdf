Commit message: perls2 clean up in progress.

File: data/robot/rethink/sawyer_description/urdf/sawyer.urdf (robot description, URDF)
Before this commit: robot sawyer, 21 links, 20 joints
Links:
- link right_hand: mass 1.0E-08 -> 1.0e-08
